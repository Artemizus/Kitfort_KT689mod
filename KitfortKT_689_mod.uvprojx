# Keil uVision project KitfortKT_689_mod.uvprojx, settings and files
target STM32f030 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: KitfortKT_689_mod +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F030x6
  c include: ..\KitfortKT_689_mod;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Code
    ./Code/src/: adc.c gpio.c i2c.c main.c rcc.c timer.c keyboard.c eeprom.c sound_pwm.c menu.c fonts.c ssd1306.c regulator.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
